<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SRAD_Radio_test.ewp</path>
  </project>
  <batchBuild />
</workspace>
